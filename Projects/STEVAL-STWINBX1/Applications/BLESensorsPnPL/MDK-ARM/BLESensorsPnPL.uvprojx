# Keil uVision project BLESensorsPnPL.uvprojx, settings and files
target BLESensorsPnPL (6140001::V6.14.1::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: BLESensorsPnPL +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c misc: -Wno-format
  c include: ../Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STWIN.box;../../../../../Middlewares/ST/PnPLCompManager/Inc;../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../Middlewares/Third_Party/parson;../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../Drivers/BSP/Components/iis2mdc;../../../../../Drivers/BSP/Components/iis2dlpc;../../../../../Drivers/BSP/Components/iis2iclx;../../../../../Drivers/BSP/Components/iis3dwb;../../../../../Drivers/BSP/Components/stts22h;../../../../../Drivers/BSP/Components/ilps22qs;../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../Drivers/BSP/Components/ST25DV
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: main.c OTA.c BLE_Function.c Configuration_PnPL.c Control_PnPL.c Deviceinformation_PnPL.c Environmental_PnPL.c Inertial_PnPL.c App_model.c IControl.c app_blesensorspnpl.c hci_tl_interface.c BLE_Implementation.c steval_stwinbx1_bus.c steval_stwinbx1.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/STWIN.box
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box_audio.c STWIN.box_bc.c STWIN.box_debug_pins.c STWIN.box_env_sensors.c STWIN.box_env_sensors_ex.c STWIN.box_motion_sensors.c STWIN.box_motion_sensors_ex.c STWIN.box_nfctag.c STWIN.box_sd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c ism330dhcx.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c iis2mdc.c
    ../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c iis2dlpc.c
    ../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx_reg.c iis2iclx.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c iis3dwb.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
    ../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs_reg.c ilps22qs.c
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_mdf.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Middlewares/PnPLCompManager/Middlewares/PnPLCompManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/PnP/PnPLike
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_PnPLike.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Environmental
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Environmental.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Inertial
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Inertial.c
  group Middlewares/STM32_BLE_Manager/BLE_Features/HardwareSensors/Battery
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Battery.c
  group Middlewares/STM32_BLE_Manager/BLE_Manager/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Manager.c
  group Middlewares/parson/Data Exchange/parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
software components: CMSIS:CORE 4.3.0
