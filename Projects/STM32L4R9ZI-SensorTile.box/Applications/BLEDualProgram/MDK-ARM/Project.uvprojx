# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9ZI-SensorTileBox (6180000::V6.18::ARMCLANG)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2009FFFF) IRAM2(0x20000000-0x2002FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BLEDualProgram +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,STM32_SENSORTILEBOX
  c misc: -Wno-format
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/SensorTile.box;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../Middlewares/Third_Party/parson
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group BLEDualProgram/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group BLEDualProgram/User
    ../Src/: BLE_Implementation.c hci_tl_interface.c main.c OTA.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../: README.md
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_bc.c SensorTile.box_bus.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Battery.c BLE_Manager.c BLE_SensorFusion.c
  group Middlewares/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/Parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 5.6.0
