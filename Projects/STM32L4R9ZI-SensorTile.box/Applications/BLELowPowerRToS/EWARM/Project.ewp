# IAR project Project.ewp, settings and files
configuration BLELowPowerRToS (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; STM32_SENSORTILEBOX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\SensorTile.box; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Drivers\BSP\Components\stts751; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Middlewares\ST\BlueNRG-2\includes; ..\..\..\..\..\Middlewares\ST\BlueNRG-2\hci\hci_tl_patterns\Basic; ..\..\..\..\..\Middlewares\ST\BlueNRG-2\utils; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_BLE_Manager\Inc; ..\..\..\..\..\Middlewares\Third_Party\parson
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: BLELowPowerRToS.bin
  ILINK.IlinkOutputFile: BLELowPowerRToS.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BLELowPowerRToS/EWARM
    ./: startup_stm32l4r9xx.s
  group BLELowPowerRToS/User
    ../Src/: BLE_Implementation.c hci_tl_interface.c HWAdvanceFeatures.c main.c PowerControl.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_audio.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AccEvent.c BLE_AudioLevel.c BLE_Battery.c BLE_Environmental.c BLE_Inertial.c BLE_Manager.c
  group Middlewares/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/json
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
