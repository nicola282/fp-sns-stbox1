# Keil uVision project Project.uvprojx, settings and files
target DataLogExtended (6180000::V6.18::ARMCLANG)
  device: STM32L4R9ZIJx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DataLogExtended +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,STM32_SENSORTILEBOX
  c misc: -Wno-format
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/SensorTile.box;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/lsm6dsox;../../../../../Drivers/BSP/Components/stts751;../../../../../Drivers/BSP/Components/lis3dhh;../../../../../Drivers/BSP/Components/lis2dw12;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
    ../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../Drivers/BSP/Components/lis3dhh/: lis3dhh.c lis3dhh_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group User/DataLogExtended
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c cube_hal_l4.c demo_serial.c sensor_commands.c serial_protocol.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c vcom.c
  group Doc
    ../: README.md
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_audio.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group Middlewares/STM32_USBD_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
