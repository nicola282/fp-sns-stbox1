# IAR project BLEDualProgram.ewp, settings and files
configuration DualProgram (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-LP/includes; ../../../../../Middlewares/ST/BlueNRG-LP/utils; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/BSP/SensorTileBoxPro; ../../../../../Drivers/BSP/Components/ST25DV; ../../../../../Drivers/BSP/Components/st25dvxxkc; ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/inc; ../../../../../Middlewares/ST/lib_nfc/Common/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLEDualProgram.bin
  ILINK.IlinkOutputFile: DualProgram.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: BLE_Implementation.c hci_tl_interface.c lib_NDEF_config.c main.c OTA.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/Components/st25dv
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/Components/st25dvkc
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc.c st25dvxxkc_reg.c
  group Drivers/SensorTileboxPro
    ../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro.c SensorTileBoxPro_bus.c SensorTileBoxPro_nfctag.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Environmental.c BLE_Inertial.c BLE_Manager.c BLE_SensorFusion.c
  group Middlewares/BlueNRG-LP/Documentation
    ../../../../../Middlewares/ST/BlueNRG-LP/doc/: BlueNRG-LP_UserManual.txt
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Controller
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/controller/: bluenrg_lp_gap_aci.c bluenrg_lp_gatt_aci.c bluenrg_lp_hal_aci.c bluenrg_lp_l2cap_aci.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/: bluenrg_lp_devConfig.c bluenrg_lp_events.c bluenrg_lp_events_cb.c bluenrg_lp_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Utils
    ../../../../../Middlewares/ST/BlueNRG-LP/utils/: ble_list.c
  group Middlewares/Lib_NDEF
    ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Bluetooth.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_Handover.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
  group Middlewares/Parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
