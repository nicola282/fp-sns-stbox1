# IAR project BLESensorsPnPL.ewp, settings and files
configuration BLESensorsPnPL (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Inc; ../PnPL/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-LP/includes; ../../../../../Middlewares/ST/BlueNRG-LP/utils; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/BSP/SensorTileBoxPro; ../../../../../Drivers/BSP/Components/Common; ../../../../../Drivers/BSP/Components/lsm6dsv16x; ../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../Drivers/BSP/Components/lps22df; ../../../../../Drivers/BSP/Components/lis2du12; ../../../../../Drivers/BSP/Components/stts22h; ../../../../../Drivers/BSP/Components/stc3115
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLESensorsPnPL.bin
  ILINK.IlinkOutputFile: BLESensorsPnPL.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: App_model.c BLE_Implementation.c hci_tl_interface.c IControl.c main.c OTA.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Application/User/PnPL
    ../PnPL/Src/: Configuration_PnPL.c Control_PnPL.c Deviceinformation_PnPL.c Environmental_PnPL.c Inertial_PnPL.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/Components/lis2du12
    ../../../../../Drivers/BSP/Components/lis2du12/: lis2du12.c lis2du12_reg.c
  group Drivers/Components/lis2mdl
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
  group Drivers/Components/lps22df
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
  group Drivers/Components/lsm6dsv16x
    ../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x.c lsm6dsv16x_reg.c
  group Drivers/Components/stc3115
    ../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/Components/stts22h
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/SensorTileboxPro
    ../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro.c SensorTileBoxPro_bus.c SensorTileBoxPro_env_sensors.c SensorTileBoxPro_gg.c SensorTileBoxPro_motion_sensors.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Battery.c BLE_Environmental.c BLE_Inertial.c BLE_Manager.c BLE_PnPLike.c
  group Middlewares/BLEComponentManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/BlueNRG-LP/Documentation
    ../../../../../Middlewares/ST/BlueNRG-LP/doc/: BlueNRG-LP_UserManual.txt
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Controller
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/controller/: bluenrg_lp_gap_aci.c bluenrg_lp_gatt_aci.c bluenrg_lp_hal_aci.c bluenrg_lp_l2cap_aci.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/: bluenrg_lp_devConfig.c bluenrg_lp_events.c bluenrg_lp_events_cb.c bluenrg_lp_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Utils
    ../../../../../Middlewares/ST/BlueNRG-LP/utils/: ble_list.c
  group Middlewares/Parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
