# Keil uVision project BLESensorsPnPL.uvprojx, settings and files
target BLESensorsPnPL (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x80FDFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: BLESensorsPnPL +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c misc: -Wno-format
  c include: ../Inc;../PnPL/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-LP/includes;../../../../../Middlewares/ST/BlueNRG-LP/utils;../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;..\..\..\..\..\Middlewares\ST\PnPLCompManager\Inc;../../../../../Middlewares/Third_Party/parson;../../../../../Drivers/BSP/SensorTileBoxPro;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/lsm6dsv16x;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/lps22df;../../../../../Drivers/BSP/Components/lis2du12;../../../../../Drivers/BSP/Components/stts22h;../../../../../Drivers/BSP/Components/stc3115
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfe000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: App_model.c BLE_Implementation.c hci_tl_interface.c IControl.c main.c OTA.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Middlewares/BLEComponentManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: PnPLCompManager.c IPnPLComponent.c
  group Application/User/PnPL
    ../PnPL/Src/: Configuration_PnPL.c Control_PnPL.c Deviceinformation_PnPL.c Environmental_PnPL.c Inertial_PnPL.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/Components/lis2du12
    ../../../../../Drivers/BSP/Components/lis2du12/: lis2du12.c lis2du12_reg.c
  group Drivers/Components/lis2mdl
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
  group Drivers/Components/lps22df
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
  group Drivers/Components/lsm6dsv16x
    ../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x.c lsm6dsv16x_reg.c
  group Drivers/Components/stc3115
    ../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/Components/stts22h
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/SensorTileboxPro
    ../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro.c SensorTileBoxPro_bus.c SensorTileBoxPro_env_sensors.c SensorTileBoxPro_gg.c SensorTileBoxPro_motion_sensors.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Battery.c BLE_Environmental.c BLE_Inertial.c BLE_Manager.c BLE_PnPLike.c
  group Middlewares/BlueNRG-LP/Documentation
    ../../../../../Middlewares/ST/BlueNRG-LP/doc/: BlueNRG-LP_UserManual.txt
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Controller
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/controller/: bluenrg_lp_gap_aci.c bluenrg_lp_gatt_aci.c bluenrg_lp_hal_aci.c bluenrg_lp_l2cap_aci.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/: bluenrg_lp_devConfig.c bluenrg_lp_events.c bluenrg_lp_events_cb.c bluenrg_lp_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-LP/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-LP/Wireless/BlueNRG-LP/Utils
    ../../../../../Middlewares/ST/BlueNRG-LP/utils/: ble_list.c
  group Middlewares/Parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
software components: CMSIS:CORE 4.3.0
