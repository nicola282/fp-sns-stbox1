# IAR project NFC_FTM.ewp, settings and files
configuration NFC_FTM (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCDiagSuppress: Pe188, Pa089
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/SensorTileBoxPro; ../../../../../Drivers/BSP/Components/ST25DV; ../../../../../Drivers/BSP/Components/st25dvxxkc; ../../../../../Middlewares/ST/ST25FTM/Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NFC_FTM.bin
  ILINK.IlinkOutputFile: NFC_FTM.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: flashl4_if.c ftm_process.c fw_command.c logger.c main.c st25ftm_config.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/Components/st25dv
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/Components/st25dvxxkc
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc.c st25dvxxkc_reg.c
  group Drivers/SensorTileboxPro
    ../../../../../Drivers/BSP/SensorTileBoxPro/: SensorTileBoxPro.c SensorTileBoxPro_bus.c SensorTileBoxPro_nfctag.c SensorTileBoxPro_nfctag_ex.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/ST25FTM
    ../../../../../Middlewares/ST/ST25FTM/Src/: st25ftm_common.c st25ftm_protocol.c st25ftm_rx.c st25ftm_tx.c
