# IAR project BLESensorsPnPL.ewp, settings and files
configuration BLESensorsPnPL (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../Inc; ../PnPL/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/BSP/STWIN.box; ../../../../../Drivers/BSP/Components/Common; ../../../../../Drivers/BSP/Components/ism330dhcx; ../../../../../Drivers/BSP/Components/iis2mdc; ../../../../../Drivers/BSP/Components/ilps22qs; ../../../../../Drivers/BSP/Components/stts22h; ../../../../../Drivers/BSP/Components/iis2dlpc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLESensorsPnPL.bin
  ILINK.IlinkOutputFile: BLESensorsPnPL.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User
    ../Src/: App_model.c BLE_Implementation.c hci_tl_interface.c IControl.c main.c OTA.c stm32u5xx_hal_msp.c stm32u5xx_it.c
  group Application/User/PnPL
    ../PnPL/Src/: Configuration_PnPL.c Control_PnPL.c Deviceinformation_PnPL.c Environmental_PnPL.c Inertial_PnPL.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32u5xx.c
  group Drivers/Components/iis2dlpc
    ../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
  group Drivers/Components/iis2mdc
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
  group Drivers/Components/ilps22qs
    ../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
  group Drivers/Components/ism330dhcx
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
  group Drivers/Components/stts22h
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/STWIN.box
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box.c STWIN.box_bc.c STWIN.box_bus.c STWIN.box_env_sensors.c STWIN.box_motion_sensors.c
  group Middlewares/BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_Battery.c BLE_Environmental.c BLE_Inertial.c BLE_Manager.c BLE_PnPLike.c
  group Middlewares/BLEComponentManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/BlueNRG-2/Controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG-2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-2/Utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/Parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
